#FILESEXTRAPATHS_prepend := "${THISDIR}/libxbee_git:"
#SRC_URI += "file://0001-bumped-to-v3.0.11.patch"
#PRINC := "${@int(PRINC) + 1}"
